# Keil uVision project Slave.uvprojx, settings and files
target Slave (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Slave
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: .;user;system\Delay;system\Library;system\start;FreeRTOS\FreeRTOS_CORE;FreeRTOS\include;FreeRTOS\portable;FreeRTOS\portable\MemMang;FreeRTOS\portable\RVDS\ARM_CM4F;GUI;Hardware\DTH22;Hardware\IR_Receiver;Hardware\MQ_Series;Hardware\OLED_v2.0;Hardware\LED;Hardware\EXTI;Hardware\Beep;system\usart
  asm define: USE_STDPERIPH_DRIVER,STM32F401xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FREERTOS/PORTABLE/RVDS/ARM_CM4F
    FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FREERTOS/PORTABLE/MEMMANG
    FreeRTOS/portable/MemMang/: heap_4.c
  group FREERTOS/FREERTOS_CORE
    FreeRTOS/FreeRTOS_CORE/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group SYSTEM/USART
    system/usart/: usart.c
  group SYSTEM/START
    system/start/: startup_stm32f401xx.s system_stm32f4xx.c
  group SYSTEM/LIBRARY
    system/Library/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM/DELAY
    system/Delay/: Delay.c
  group USER
    user/: main.c stm32f4xx_it.c
  group HARDWARE/REMOTE
    Hardware/REMOTE/: remote.c
  group HARDWARE/OLED_V2.0
    Hardware/OLED_v2.0/: OLED.c OLED_Data.c
  group HARDWARE/MQ_SERIES
    Hardware/MQ_Series/: MQ_Series.c
  group HARDWARE/LED
    Hardware/LED/: LED.c
  group HARDWARE/DTH22
    Hardware/DTH22/: DHT22.c
  group HARDWARE/BEEP
    Hardware/Beep/: Beep.c
